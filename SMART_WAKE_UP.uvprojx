# Keil uVision project SMART_WAKE_UP.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SMART_WAKE_UP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group src
    ./src/: gpio.c main.c servo.c tim.c urm37.c usart.c st7920.c ds3231.c buttons.c sh1106.c
  group inc
    ./inc/: gpio.h servo.h tim.h urm37.h usart.h st7920.h ds3231.h buttons.h sh1106.h
  group fonts
    ./Fonts/: fonts.h fonts_arial12x12.c fonts_arial28x28.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.5
